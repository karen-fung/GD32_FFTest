# Keil uVision project GD32_Func.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F103VE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD32_Func +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CMSIS;..\Moudle;..\StdPeriphLib\Include;..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/: core_cm3.h core_cmFunc.h core_cmInstr.h gd32f10x.h gd32f10x_libopt.h startup_gd32f10x_hd.s system_gd32f10x.c system_gd32f10x.h
  group StdPeriphLib
    ../StdPeriphLib/Include/: gd32f10x_adc.h gd32f10x_bkp.h gd32f10x_can.h gd32f10x_crc.h gd32f10x_dac.h gd32f10x_dbg.h gd32f10x_dma.h gd32f10x_enet.h gd32f10x_exmc.h gd32f10x_exti.h gd32f10x_fmc.h gd32f10x_fwdgt.h gd32f10x_gpio.h gd32f10x_i2c.h gd32f10x_misc.h gd32f10x_pmu.h gd32f10x_rcu.h gd32f10x_rtc.h gd32f10x_sdio.h gd32f10x_spi.h gd32f10x_timer.h gd32f10x_usart.h gd32f10x_wwdgt.h
    ../StdPeriphLib/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group User
    ../User/: gd32f10x_it.c gd32f10x_it.h main.c
